Commit message: removed blue ball

File: environments/assets/robot/ur10e.urdf (robot description, URDF)
Before this commit: robot ur10e, 26 links, 25 joints
Links:
- link tcp_link: geometry 
